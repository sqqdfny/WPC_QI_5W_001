# Keil uVision project Project.uvproj, settings and files
target debug (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: debug +hex
  AfterMake: _build_debug_out.bat
  c flags: Optimize=8 SizeSpeed=1
  c define: DEBUG
  c include: .\Include;.\common;.\qi;.\led
  group startup
    ./Startup/: STARTUP.A51
  group main
    ./main/: main.c
  group inc
    ./Include/: Function_Define.h includes.h N76E003.h SFR_Macro.h typedef.h
    ./: main.lin
  group common
    ./common/: delay.c adc.c
  group qi
    ./qi/: qi.c
  group led
    ./led/: led.c
target release (MCS-51)
  device: N76E003 Nuvoton
  cpu: as above
  output: release +hex
  AfterMake: _build_release_out.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include;.\common;.\qi;.\led
