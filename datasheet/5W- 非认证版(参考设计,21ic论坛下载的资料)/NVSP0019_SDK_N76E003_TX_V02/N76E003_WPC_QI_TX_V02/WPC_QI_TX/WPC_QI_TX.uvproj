# Keil uVision project WPC_QI_TX.uvproj, settings and files
target WPC_QI_TX (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: NVSP0019 +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include;.\User\inc
  group Source
    ./User/src/: hardware.c main.c ctrl.c NVSP0019.LIB
  group Startup
    ../Startup/: STARTUP.A51
